Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Filling Unit_MEPcontent_Spirotech_SpiroPure ProClean 9.5_INT-EN.ifc
Time: 2025-08-05T18:29:36+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Filling Unit_MEPcontent_Spirotech_SpiroPure ProClean_INT-EN:SpiroPure ProClean 9.5, M_Filling Unit_MEPcontent_Spirotech_SpiroPure ProClean_INT-EN:SpiroPure ProClean 9.5:2055873
In: F00
Type - Material: Color RGB 055-055-055 (2), Color RGB 168-128-048 (2), Color RGB 150-150-150, Color RGB 255-255-255, Color RGB 255-000-000, <Unnamed>, Color RGB 229-190-001
Type - Other - Category: Mechanical Equipment; 23: no; 9.5: yes; Family Name: M_Filling Unit_MEPcontent_Spirotech_SpiroPure ProClean_INT-EN
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 519 mm; Drain Connection Diameter: 19 mm; Height: 1182 mm; Use Nominal Diameter: yes; Water Inlet Connection Diameter: 19 mm; Water Outlet Connection Diameter: 19 mm; Width: 528 mm
Type - Electrical - Power Supply LED: Battery - CR2450; Voltage: 230 V
Type - Identity Data - Article Description: Mobile cleaning and filling station - cap. 1350 ltr - SpiroTrap MBC; Article Type: SpiroPure ProClean 9.5; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: ©Trimble Europe BV; Custom: no; Description: Mobile cleaning and filling station - cap. 1350 ltr - SpiroTrap MBC; EMCS Version: 5.0; ETIM Article Class: EC010980; Family Version: 24.10; GLN: 8717811000007; GTIN: 8717811064610; Manufacturer: Spirotech; Manufacturer Art. No.: G76.361; Manufacturer URL: https://www.spirotech.com/8717811064603; MEPcontent Class: PUMP; Model: SpiroPure ProClean 9.5; OmniClass Number: 23.75.50.11.14; OmniClass Title: Feedwater Equipment; Product Line: Spirotech; Revit Version: 2023; Type Name: SpiroPure ProClean 9.5; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Dark Yellow: Color RGB 168-128-048; Grey: Color RGB 150-150-150; Red: Color RGB 255-000-000; White: Color RGB 255-255-255
Type - Mechanical - Drain Fixture Units: 0; Max Filling Capacity: 1.35 m3; Resin Volume: 0.0095 m3; Weight: 36.7 kg; Working Pressure: 1 to 8 bar; Working Temperature: 5 to 80°C
Type - Mechanical - Flow - Max Flow: 0.000166667 m3/s
Type - Text - Pipe Type Category: M561
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Material: Color RGB 055-055-055, Color RGB 168-128-048, Color RGB 150-150-150, Color RGB 255-255-255, Color RGB 255-000-000, <Unnamed>, Color RGB 229-190-001
Pset_BuildingElementProxyCommon - Reference: SpiroPure ProClean 9.5; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: SpiroPure ProClean 9.5
Other - Family: M_Filling Unit_MEPcontent_Spirotech_SpiroPure ProClean_INT-EN; Family and Type: M_Filling Unit_MEPcontent_Spirotech_SpiroPure ProClean_INT-EN: SpiroPure ProClean 9.5; Type: SpiroPure ProClean 9.5; Type Id: 2055856
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 3.82657 m2; Volume: 0.049151 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined,Power,Sanitary; Water Inlet Connection Flow: 0 m3/s; Water Outlet Connection Flow: 0 m3/s
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection | PredefinedType
InPort_2055873_1 | SINK | PIPE
OutPort_2055873_2 | SOURCE | PIPE
Port_2055873_3 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
OutPort_2055873_4 | SOURCE | PIPE | SystemType: SEWAGE
